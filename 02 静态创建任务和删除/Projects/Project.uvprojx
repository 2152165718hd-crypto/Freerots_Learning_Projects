# Keil uVision project Project.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\CMSIS\Include;..\Drivers;..\Users;..\Middlewares\FreeROTS\include;..\Middlewares\FreeROTS\portable\RVDS\ARM_CM3;..\Middlewares
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group User
    ../Users/: main.c stm32f1xx_it.c FreeROTS_Demo.c FreeROTS_Demo.h
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SYSTEM
    ../Drivers/SYSTEM/delay/: delay.c delay.h
    ../Drivers/SYSTEM/sys/: sys.c sys.h
    ../Drivers/SYSTEM/usart/: usart.c usart.h
  group Drivers/STM32F1xx_HAL_Driver.Inc
    ../Drivers/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal.h stm32f1xx_hal_cortex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_rcc.h stm32f1xx_hal_uart.h stm32f1xx_hal_usart.h stm32f1xx_hal_dma.h stm32f1xx_hal_tim.h
  group Drivers/STM32F1xx_HAL_Driver.Src
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Middleware/FreeROTS
    ../Middlewares/FreeROTS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/FreeROTS/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/FreeROTS/portable/MemMang/: heap_4.c
    ../Middlewares/FreeROTS/include/: FreeRTOSConfig.h
  group Drivers/Hardware
    ../Drivers/Hardware/LED/: LED.c LED.h
    ../Drivers/Hardware/OLED/: OLED.c OLED.h OLED_Font.h OLED_Font.c
    ../Drivers/Hardware/KEY/: KEY.c KEY.h
    ../Drivers/Hardware/TIMER/: Timer.c Timer.h
