# Keil uVision project Project.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\CMSIS\Include;..\Drivers;..\Users;..\Middleware\FreeRTOS\Source\include;..\Middleware\FreeRTOS\Source\Portable\RVDS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../Users/: main.c FreeRTOS_Demo.c stm32f4xx_it.c stm32f4xx_hal_timebase_tim.c FreeRTOSConfig.h
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/System
    ../Drivers/SYSTEM/sys/: sys.c sys.h
    ../Drivers/SYSTEM/usart/: usart.c usart.h
    ../Drivers/SYSTEM/delay/: delay.c delay.h
  group Drivers/_HAL_Drivers
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Hardware
    ../Drivers/Hardware/LCD/: LCD.c LCD.h LCD_Data.c LCD_Data.h
  group FreeRTOS_Source
    ../Middleware/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_Portable
    ../Middleware/FreeRTOS/Source/Portable/RVDS/: port.c
    ../Middleware/FreeRTOS/Source/Portable/MemMang/: heap_4.c
